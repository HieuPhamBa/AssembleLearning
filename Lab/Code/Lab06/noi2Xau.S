; NOI 2 XAU
	AREA RESET, DATA, READONLY
		DCD 0X20002000
		DCD MAIN
	AREA DATA1, DATA, READONLY
DT1 DCB "THIEN MENH", 0; XAU KET THUC VOI KI TU NULL
	AREA DATA2, DATA, READONLY
DT2 DCB "ANH HUNG",0
	AREA DATA3, DATA, READWRITE
DT3 DCB 0; KETQUA
	AREA HUU, CODE, READONLY
	ENTRY
MAIN
	LDR R0, =DT1
	LDR R1, =DT3
LOOP; PHAI CHECK XEM NO CO PHAI LA NULL K TRUOC KHI STRORE LAI
	LDRB R2, [R0], #1
	CMP R2, #0
	BEQ TG
	STRB R2, [R1], #1
	B LOOP
TG
	MOV R2, #64;  LA DAU CACH
	STRB R2, [R1], #1
	LDR R0, =DT2
	B LOOP2
LOOP2; STRORE LUON NULL DE LAM KITU KET THUC XAU
	LDRB R2, [R0], #1
	STRB R2, [R1], #1
	CMP R2, #0
	BEQ STOP
	B LOOP2
STOP
	END