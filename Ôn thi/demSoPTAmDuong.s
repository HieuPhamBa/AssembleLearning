	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD Reset_Handler

MATRAN 	DCD 1, 2, 3
		DCD	-4, 5, 6
		DCD 7, -8, 9

	AREA MYCODE, CODE, READONLY
		ENTRY

Reset_Handler
	LDR R0, =MATRAN; TRO DEN DIA CH MA TRAN
	MOV R1, #9; SO PHAN TU TRONG MATRAN

	MOV R2, #0; DEM PTU DUONG
	MOV R3, #0; DEM PTU AM

SOSANH
	LDR R5, [R0]
  	CMP R5, #0
	BGT DUONG
	CMP R5, #0
	BLT AM

LOOP; NHAN
	ADD R0, #4
	SUB R1, #1;
	CMP R1, #0
	BGT SOSANH
	B STOP



DUONG
	ADD R2, #1
	B LOOP

AM 
	ADD	R3, #1
	B LOOP

STOP
	B STOP
	END
