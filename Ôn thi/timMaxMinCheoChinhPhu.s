	AREA RESET, DATA, READONLY
		DCD 0X20001000
		DCD Reset_Handler

MATRAN 	DCD 1, 3, 7
		DCD 7, 6, 8
		DCD 9, 2, 5

	AREA MYCODE, CODE, READONLY
		ENTRY

Reset_Handler
	 LDR R0, =MATRAN; LAY DIA CHI MATRAN
	 MOV R1, #3; CO 9 PHAN TU , DONG THOI LA BIEN CHAY NGUOC
	 MOV R2, #1;MAX CHINH
	 MOV R3, #1;MIN CHINH

;	 MOV R5, #7; MAX PHU
;	 MOV R6, #7; MIN PHU

SOSANH
	LDR R4, [R0]
	CMP R4, R2
	BGT MAX
	CMP R4, R3
	BLT MIN

LOOP
	ADD R0, #16; MA TRAN 3X3 THI SO PHAN TU CAC NHAU TREN DUONG CHEO CHINH LA 4 PHAN TU, MOI PHAN TU CACH NHAU 4 BYTE
	SUB R1, #1
	CMP R1, #0
	BGT SOSANH
	B STOP		

MAX
	MOV  R2,R4
	B LOOP

MIN 
	MOV R3, R4
	B LOOP

STOP
	B STOP
	END
; cheo phu
//SOSANH_P
//	LDR R7, [R0]
//	CMP R7, R5
//	BGT MAX_P
//	CMP R7, R6
//	BLT MIN_P
//
//LOOP_P
//	ADD R0, #8
//	SUB R1, #1
//	CMP R1, #0
//	BGT SOSANH_P
//	B STOP
//
//MAX_P
//	MOV  R5,R7
//	B LOOP_P
//
//MIN_P 
//	MOV R6, R7
//	B LOOP_P

