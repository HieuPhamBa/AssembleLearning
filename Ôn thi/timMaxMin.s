	 AREA RESET, DATA, READONLY
	 	DCD 0X20001000
		DCD Reset_Handler

CHUOI DCD 2,1,8,5,4,3,9

	 AREA MYCODE, CODE, READONLY

Reset_Handler
	MOV R0, #2; LUU MAX
	MOV R1, #2; LUU MIN
	MOV R2, #7; CHUA 7 PHAN TU
	LDR R3, = CHUOI; LAY DIA CHI CHUOI
	MOV R4, #0; BIEN DEM

SoSanh
	LDR R5, [R3]; LAY GIA TRI CUA TUNG PHAN TU CUA CHUOI THEO DCD
	CMP R5, R0;SO SANH MAX VOI R5
	BGT MAX
	CMP R5, R1
	BLT MIN
	B LOOP

LOOP
	ADD R3, #4
	ADD R4, #1;TANG BIEM DEM
	CMP R4,R2
	BLT SoSanh
	B STOP
	
MAX
	MOV R0, R5
	B LOOP
	
MIN 
	MOV R1, R5
   	B LOOP
	
STOP
	B STOP

	END 	