	AREA RESET,DATA,READONLY
	EXPORT VECTOR
VECTOR DCD 0X20001000
		DCD RESET_HANDLE
	AREA MYDATA,DATA,READONLY
	
MATRAN 
	DCD 4,2,8
	DCD 1,2,1
	DCD 3,7,12
	
	AREA MYCODE,CODE,READONLY
		ENTRY
SOCHAN PROC
	LDR R4,[R0],#4
	MOV R5,#2
	SDIV R6,R4,R5
	MLS R7,R6,R5,R4	
	CMP R7,#0
	BEQ PROCESS
	B EXIT
	
FIRST
	ADD R8,#1	
	MOV R1,R4
	MOV R2,R4	
	B EXIT
	
PROCESS
	CMP R8,#0
	BEQ FIRST 	
	CMP R4,R1
	BGT MAX
	B LOOP1
	
LOOP1 
	CMP R4,R2
	BLT MIN
	B EXIT
MAX
	MOV R1,R4
	B LOOP1

MIN
	MOV R2,R4
	B EXIT
	
EXIT
	ADD R3,#1
	CMP R3, #9
	BLT SOCHAN
	BX LR
	ENDP
RESET_HANDLE
MAIN PROC
	LDR R0,=MATRAN
	MOV R3,#0
	mov R1,#0
	mov R2,#0
	mov r8,#0
	BL SOCHAN
	ENDP
	END